LINUX_VERSION ?= "5.2.21"
LINUX_RPI_BRANCH ?= "rpi-5.2.y"

SRCREV = "94dbfa7606fc2f3df44979ed9c2d1d3676f2c159"

require linux-raspberrypi_5.2.inc
