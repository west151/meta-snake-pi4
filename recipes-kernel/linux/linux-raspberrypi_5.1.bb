LINUX_VERSION ?= "5.1.21"
LINUX_RPI_BRANCH ?= "rpi-5.1.y"

SRCREV = "29ee73a82540e8b94c6bde0ad1acae65f73653ea"

require linux-raspberrypi_5.1.inc
