LINUX_VERSION ?= "5.3.18"
LINUX_RPI_BRANCH ?= "rpi-5.3.y"

SRCREV = "32ba05a62a8071d091d7582cc37b4bac2962b1dd"

require linux-raspberrypi_5.3.inc
